# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED=1,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\USER;..\UCOS-III\uC-CPU;..\UCOS-III\uC-LIB;..\UCOS-III\uCOS-III;..\UCOS-III\UCOS_BSP;..\UCOS-III\uCOS_CONFIG;..\UCOS-III\uCOS-III\Source;..\UCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\UCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE;..\STM32\CORE;..\STM32\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\TASK;..\DSP-LIB;..\DSP-LIB\inc;..\HARDWARE\mpu6050_42mm
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group TASK
    ../TASK/: gimbal_task.c chasis_task.c gun_task.c start_task.c task.h time_task.c
  group STM32_CORE
    ../STM32/CORE/: core_cm4.h core_cm4_simd.h startup_stm32f427xx.s
  group STM32_LIB
    ../STM32/FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32_HARDWARE
    ../HARDWARE/: delay.c sys.c imu.c uart6.c uart1.c gpio.c can1.c pwm.c can2.c uart3.c imu_data_decode.c packet.c pstwo.c gimbal_min_task.c can1.h can2.h delay.h gpio.h imu.h imu_data_decode.h INST.h packet.h pstwo.h pwm.h SCS.h SCServo.h SMS_STS.h sys.h uart1.h uart3.h uart6.h
    ./: usart69050.c
  group UCOSIII_BSP
    ../UCOS-III/UCOS_BSP/: bsp.c
  group UCOSIII_LIB
    ../UCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CPU
    ../UCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
    ../UCOS-III/uC-CPU/: cpu_core.c
  group UCOSIII_PORT
    ../UCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CORE
    ../UCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_CONFIG
    ../UCOS-III/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group DSP_LIB
    ../UCOS-III/: arm_cortexM4lf_math.lib
